# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Thermal_V116 +hex
  AfterMake: h:\Program Files\keil 4\ARM\ARMCC\bin\fromelf.exe  --bin -o ..\OBJ\Thermal_V116.bin ..\OBJ\Thermal_V116.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCDDriver;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\SDIO;..\FATFS;..\FATFS\doc;..\FATFS\exfuns;..\FATFS\src;..\FATFS\doc\en;..\FATFS\doc\img;..\FATFS\doc\ja;..\FATFS\src\option;..\bmp
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c VarDefine.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCDDriver/: LCD.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../bmp/: bmp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_flash.c
  group FATFS
    ../FATFS/: malloc.c
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
